*question3
v1 1 0 sin(0 4 0.159 0 60 0 1)
r1 1 2 {RLOAD}
l1 2 0 2
e1 2 3 1 2 4
r2 3 0 4
c1 1 3 1
.step param RLOAD 1 100 10
.trans 1 100
