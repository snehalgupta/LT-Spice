*question 2
v1 1 0 sin(0 120 0.159 0 60 0 1)
r1 1 2 80
l1 2 3 60
r2 3 0 90
c1 3 0 0.0333
RL 3 0 {RLOAD}
.step param RLOAD 1 100 10
.trans 1 100
